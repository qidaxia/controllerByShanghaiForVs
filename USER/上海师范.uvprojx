# Keil uVision project 上海师范.uvprojx, settings and files
target 第一版 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 植物扫描 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\FWLIB\inc;..\HARDWARE\USART1;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\UART5;..\HARDWARE\TIMER3;..\HARDWARE\RTC;..\HARDWARE\ADC;..\HARDWARE\USART6;..\DESIGN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c init_Parameter.c PlanTask.c Test.c toSensor.c PC_Dealwith.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_pwr.c
  group DESIGN
    ../DESIGN/: design.c
  group h
    ./: main.h
    ../HARDWARE/TIMER3/: timer3.h
  group README
    ../: readme.txt
